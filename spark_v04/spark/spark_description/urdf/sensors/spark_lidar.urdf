Commit message: add lidar amcl function

File: spark_v04/spark/spark_description/urdf/sensors/spark_lidar.urdf (robot description, URDF)
Before this commit: robot lidar_frame, 1 links, 1 joints
Joints:
- joint lidar_joint: origin xyz=0 0 0.08 rpy=3.14 3.14 3.14 -> xyz=0 0 0.08 rpy=3.14 3.14 3.75
